Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Nami - Sunbed - ver4.ifc
Time: 2024-01-12T09:34:41
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (8)
Name
 | Nami - Sunbed model_0 - ObjectType: SketchupGroup
 | Nami - Sunbed model_1 - ObjectType: SketchupGroup
 | Nami - Sunbed model_2 - ObjectType: SketchupGroup
 | Nami - Sunbed model_3 - ObjectType: SketchupGroup
 | Nami - Sunbed model_4 - ObjectType: SketchupGroup
 | Nami - Sunbed model_5 - ObjectType: SketchupGroup
 | Nami - Sunbed model_6 - ObjectType: SketchupGroup
 | Nami - Sunbed model_7 - ObjectType: SketchupGroup
